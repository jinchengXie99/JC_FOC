# Keil uVision project JC_FOC.uvprojx, settings and files
target JC_FOC (6220000::V6.22::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: JC_FOC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;./User;../User/APP;../User/Framework;../User/Function;../User/MCUDriver;../User/PeripheralsDriver;../User/utils
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group APP
    ../User/APP/: APPMain.c APPMain.h
  group MCU
    ../User/MCUDriver/: ADC1.c ADC1.h ADC2.c ADC2.h CAN1.c CAN1.h GPIONVIC.c GPIONVIC.h LEDGPIO.c LEDGPIO.h MCUDriverMain.c MCUDriverMain.h MotorGPIO.c MotorGPIO.h SPI3.c SPI3.h TIM1PWM.c TIM1PWM.h TIM4Encoder.c TIM4Encoder.h Timer.c Timer.h
  group PERdriver
    ../User/PeripheralsDriver/: DRV8301Config.c DRV8301Config.h FOCConfig.c FOCConfig.h LEDConfig.c LEDConfig.h PerDriverMain.c PerDriverMain.h PositionPIDConfig.c PositionPIDConfig.h SpeedPIDConfig.c SpeedPIDConfig.h SvpwmConfig.c SvpwmConfig.h
  group Function
    ../User/Function/: FunctionMain.c FunctionMain.h
  group Framework
    ../User/Framework/: DRV8301.c DRV8301.h FOC.c FOC.h LEDControl.c LEDControl.h PositionPID.c PositionPID.h SpeedPID.c SpeedPID.h Svpwm.c Svpwm.h
  group utils
    ../User/utils/: fast_sin.h vofa.h
software components: CMSIS:CORE 6.1.0
